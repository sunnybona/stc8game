# Keil uVision project Tiny_Stc_Breakout.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: Tiny_Stc_Breakout +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 font6x8.h globals.h ssd1306xled.h ssd1306xled.c main.c
